# Keil uVision project BUM.uvprojx, settings and files
target BUM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BUM +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: .\CMSIS;.\MAIN;.\SPL\inc;.\SPL\src;.\StartUp;.\Services;.\Library;.\MilliG;.\hd44780
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: startup_stm32f10x_md.s
  group MAIN
    ./MAIN/: main.c
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group SPL
    ./SPL/src/: misc.c stm32f10x_exti.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c
  group Services
    ./Services/: time_service.c
  group Library
    ./Library/: self_control.c pwm.c motor.c buttons.c
